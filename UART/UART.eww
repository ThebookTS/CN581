<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Uart_MSP430G2253\Uart_MSP430G2253.ewp</path>
    </project>
    <batchBuild />
</workspace>
