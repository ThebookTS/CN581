<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Code_DA_01\Code_DA_01.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Code_DA_02\Code_DA_02.ewp</path>
    </project>
    <batchBuild />
</workspace>
